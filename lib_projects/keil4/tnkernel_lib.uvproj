# Keil uVision project tnkernel_lib.uvproj, settings and files
target ARM7TDMI (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: tnkernel (library)
  c flags: oTime=1 OneElfS=1 uC99=1
  c include: ..\..\src\include
  group arch
    ../../src/arch/arm/: tn_port_arm_armcc.c
    ../../src/arch/cortex_m0/: tn_port_cm0.c tn_port_cm0_armcc.s
    ../../src/arch/cortex_m3/: tn_port_cm3.c tn_port_cm3_armcc.s
  group kernel
    ../../src/kernel/: tn.c tn_delay.c tn_dqueue.c tn_event.c tn_mem.c tn_message_buf.c tn_mutex.c tn_sem.c tn_sprintf.c tn_tasks.c tn_timer.c tn_utils.c
target Cortex M0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: tnkernel (library)
  c flags: oTime=1 OneElfS=1 uC99=1
  c include: ..\..\src\include
target Cortex M3 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: tnkernel (library)
  c flags: oTime=1 OneElfS=1 uC99=1
  c include: ..\..\src\include
target Cortex M4 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: tnkernel (library)
  c flags: oTime=1 OneElfS=1 uC99=1
  c include: ..\..\src\include
