# Keil uVision project stm32f4_example_timers.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f4_example_timers
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx
  c include: ..\..\..\..\..\..\src\CMSIS\Core\Include;..\..\..\..\..\..\src\Config;..\..\..\..\..\..\src\include;..\..\src\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group RTOS
    ../../../../../../src/Config/: RTOS_Config.c
    ../../../../../../src/kernel/: dataqueue.c delay.c event.c kernel.c mempool.c message_que.c mutex.c os_lib.c que.c semaphore.c thread.c timer.c
    ../../../../../../src/kernel/ARM/: irq_cm3.s
  group src
    ../../src/: stm32f4_example_timers.c
    ../../src/Device/: system_stm32f4xx.c
    ../../src/Device/arm/: startup_stm32f407xx.s
