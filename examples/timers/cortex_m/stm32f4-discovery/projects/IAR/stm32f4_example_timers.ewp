# IAR project stm32f4_example_timers.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32F407xx
  ICCARM.CCIncludePath2: ..\..\src\include; ..\..\..\..\..\..\src\CMSIS\Core\Include; ..\..\..\..\..\..\src\Config; ..\..\..\..\..\..\src\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32f4_example_timers.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\src\Device\iar\stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group RTOS
    ../../../../../../src/kernel/: dataqueue.c delay.c event.c kernel.c mempool.c message_que.c mutex.c os_lib.c que.c semaphore.c thread.c timer.c
    ../../../../../../src/kernel/IAR/: irq_cm3.s
    ../../../../../../src/Config/: RTOS_Config.c
  group src
    ../../src/: stm32f4_example_timers.c
  group src/Device
    ../../src/Device/iar/: startup_stm32f407xx.s
    ../../src/Device/: system_stm32f4xx.c
