# Keil uVision project stm32f0_example_event_flags.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f0_example_event_flags
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F051
  c include: ..\..\src\include;..\..\..\..\..\..\src\include;..\..\..\..\..\..\src\arch\cortex_m
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group src
    ../../src/: stm32f0_example_event_flags.c
    ../../src/init/: system_stm32f0xx.c startup_stm32f051.s
  group uKernel
    ../../../../../../src/kernel/: data_que.c delay.c event.c mem.c message_que.c mutex.c que.c semaphore.c system.c task.c timer.c
    ../../../../../../src/arch/cortex_m/: hal_cm.c
