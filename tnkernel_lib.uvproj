# Keil uVision project tnkernel_lib.uvproj, settings and files
target Cortex M3 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: tnkernel_cm3 (library)
  AfterMake: cmd.exe /C move .\cortex\tnkernel_cm3.lib .\tnkernel_cm3.lib
  c flags: oTime=1 OneElfS=1
  c misc: --C99
  c include: .\src\include
  group src
    ./src/: tn.c tn_delay.c tn_dqueue.c tn_event.c tn_mem.c tn_mutex.c tn_sem.c tn_sprintf.c tn_tasks.c tn_timer.c tn_utils.c
    ./src/cortex_m3/: tn_port_cm3.c tn_port_cm3_armcc.s
    ./src/arm/: tn_port_arm_armcc.c
    ./template/: tn_config.c
target ARM (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: tnkernel_arm (library)
  AfterMake: cmd.exe /C move .\arm\tnkernel_arm.lib .\tnkernel_arm.lib
  c flags: oTime=1 OneElfS=1
  c misc: --C99
  c include: .\src\include
target Cortex M4 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: tnkernel_cm4 (library)
  AfterMake: cmd.exe /C move .\cortex\tnkernel_cm4.lib .\tnkernel_cm4.lib
  c flags: oTime=1 OneElfS=1
  c misc: --C99
  c include: .\src\include
